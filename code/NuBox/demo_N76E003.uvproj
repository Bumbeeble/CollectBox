# Keil uVision project demo_N76E003.uvproj, settings and files
target BET_608 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: demo_N76E003 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user;.\hardware;.\hardware\adc;.\hardware\wdt;.\hardware\led;.\hardware\bat;.\hardware\delay;.\hardware\halfduplex;.\hardware\output;.\hardware\sleep;.\hardware\uart;.\system;.\hardware\LiquidCrystal_I2C;.\hardware\i2c_simu;.\hardware\encoder;.\hardware\buzzer;.\hardware\button
  group user
    ./user/: main.c
  group hardware
    ./hardware/adc/: adc.c
    ./hardware/wdt/: wdt.c
    ./hardware/led/: led.c
    ./system/: sys_tim.c
    ./hardware/delay/: delay.c
    ./hardware/uart/: uart.c
    ./hardware/: define.c sys_init.c
    ./hardware/LiquidCrystal_I2C/: LiquidCrystal_I2C.c
    ./hardware/i2c_simu/: i2c_simu.c
    ./hardware/encoder/: encoder.c
    ./hardware/button/: button.c
    ./hardware/buzzer/: buzzer.c
  group Note
    ./user/: Note_BTE608.txt
  group Startup
    ./Startup/: STARTUP.A51
